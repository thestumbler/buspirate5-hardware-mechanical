File: pcb/mech/mech.kicad_pcb (KiCad board)
At the start: 4 copper layers, 60.5 x 60 mm, 0 parts

Commit message: clean up directory names
Other:
- board outline removed

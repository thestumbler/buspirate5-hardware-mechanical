File: pcb/REV10/leds.kicad_sch (KiCad schematic)
At the start: 37 parts

Commit message: making chris branch
Parts:
- gave numbers to parts that had none: 11
